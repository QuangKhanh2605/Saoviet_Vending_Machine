# IAR project Saoviet_Maybanhang.ewp, settings and files
configuration Saoviet_Maybanhang (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_comm; ..\user_app\user_app_vending_machine; ..\user_app\user_app_vending_machine\user_app_ctrl_motor; ..\user_app\user_app_vending_machine\user_app_door_sensor; ..\user_app\user_app_vending_machine\user_app_electric; ..\user_app\user_app_vending_machine\user_app_pc_box; ..\user_app\user_app_vending_machine\user_app_relay; ..\user_app\user_app_vending_machine\user_app_temperature; ..\user_app\user_app_vending_machine\user_app_vib_sensor; ..\user_app\user_app_vending_machine\user_comm_vending_machine; ..\user_app\user_app_vending_machine\user_irq_input; ..\user_app\user_uart; ..\user_eventdriven; ..\user_util; ..\user_component\user_mem; ..\user_component\user_mem\user_internal_mem; ..\user_component\user_mem\user_external_flash; ..\user_component\user_mem\user_external_flash\external_flash_S25FL216K; ..\user_queue; ..\user_app\user_at_serial; ..\user_app\user_app_at_debug
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Saoviet_Maybanhang.hex
  ILINK.IlinkOutputFile: Saoviet_Maybanhang.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
  group user_app/user_app_at_debug
    ../user_app/user_app_at_debug/: user_app_at_debug.c user_app_at_debug.h
  group user_app/user_app_common
    ../user_app/user_app_comm/: user_app_comm.c user_app_comm.h
  group user_app/user_app_vending_machine
    ../user_app/user_app_vending_machine/: user_inc_vending_machine.h
  group user_app/user_app_vending_machine/user_app_ctrl_motor
    ../user_app/user_app_vending_machine/user_app_ctrl_motor/: user_app_ctrl_motor.c user_app_ctrl_motor.h
  group user_app/user_app_vending_machine/user_app_door_sensor
    ../user_app/user_app_vending_machine/user_app_door_sensor/: user_app_door_sensor.c user_app_door_sensor.h
  group user_app/user_app_vending_machine/user_app_electric
    ../user_app/user_app_vending_machine/user_app_electric/: user_app_electric.c user_app_electric.h
  group user_app/user_app_vending_machine/user_app_pc_box
    ../user_app/user_app_vending_machine/user_app_pc_box/: user_app_pc_box.c user_app_pc_box.h
  group user_app/user_app_vending_machine/user_app_relay
    ../user_app/user_app_vending_machine/user_app_relay/: user_app_relay.c user_app_relay.h
  group user_app/user_app_vending_machine/user_app_temperature
    ../user_app/user_app_vending_machine/user_app_temperature/: user_app_temperature.c user_app_temperature.h
  group user_app/user_app_vending_machine/user_app_vib_sensor
    ../user_app/user_app_vending_machine/user_app_vib_sensor/: user_app_vib_sensor.c user_app_vib_sensor.h
  group user_app/user_app_vending_machine/user_comm_vending_machine
    ../user_app/user_app_vending_machine/user_comm_vending_machine/: user_comm_vending_machine.c user_comm_vending_machine.h
  group user_app/user_app_vending_machine/user_irq_input
    ../user_app/user_app_vending_machine/user_irq_input/: user_irq_input.c user_irq_input.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_external_flash
    ../user_component/user_mem/user_external_flash/: user_external_flash.c user_external_flash.h
  group user_component/user_external_flash/external_flash_S25FL216K
    ../user_component/user_mem/user_external_flash/external_flash_S25FL216K/: S25FL216K.c S25FL216K.h
  group user_component/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_modbus_rtu.c user_modbus_rtu.h user_string.c user_string.h user_util.c user_util.h
