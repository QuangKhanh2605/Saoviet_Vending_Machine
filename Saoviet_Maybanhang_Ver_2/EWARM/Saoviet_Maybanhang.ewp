# IAR project Saoviet_Maybanhang.ewp, settings and files
configuration Saoviet_Maybanhang (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_comm; ..\user_app\user_app_vending_machine; ..\user_app\user_app_vending_machine\user_app_ctrl_motor; ..\user_app\user_app_vending_machine\user_app_door_sensor; ..\user_app\user_app_vending_machine\user_app_electric; ..\user_app\user_app_vending_machine\user_app_pc_box; ..\user_app\user_app_vending_machine\user_app_relay; ..\user_app\user_app_vending_machine\user_app_temperature; ..\user_app\user_app_vending_machine\user_app_vib_sensor; ..\user_app\user_app_vending_machine\user_comm_vending_machine; ..\user_app\user_app_vending_machine\user_irq_input; ..\user_app\user_uart; ..\user_eventdriven; ..\user_util; ..\user_queue; ..\user_app\user_at_serial; ..\user_component\user_convert_variable; ..\user_timer; ..\user_app\user_app_mem; ..\user_app\user_log; ..\user_component\user_mem; ..\user_component\user_mem\user_external_flash\external_flash_S25FL216K; ..\user_component\user_mem\user_external_flash; ..\user_component\user_mem\user_internal_mem; ..\user_app\user_app_sim; ..\user_component\mqtt_lib\inc; ..\user_component\user_sim; ..\user_component\user_sim\user_ec200u; ..\user_app\user_app_vending_machine\user_app_rs485
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Saoviet_Maybanhang.bin
  ILINK.IlinkOutputFile: Saoviet_Maybanhang.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c gpio.c main.c rtc.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
  group user_app/user_app_common
    ../user_app/user_app_comm/: user_app_comm.c user_app_comm.h user_define.h user_modem.c user_modem.h user_modem_init.c user_modem_init.h
  group user_app/user_app_mem
    ../user_app/user_app_mem/: user_app_mem.c user_app_mem.h
  group user_app/user_app_sim
    ../user_app/user_app_sim/: user_app_sim.c user_app_sim.h user_mqtt.c user_mqtt.h
  group user_app/user_app_vending_machine
    ../user_app/user_app_vending_machine/: user_inc_vending_machine.h
  group user_app/user_app_vending_machine/user_app_ctrl_motor
    ../user_app/user_app_vending_machine/user_app_ctrl_motor/: user_app_ctrl_motor.c user_app_ctrl_motor.h
  group user_app/user_app_vending_machine/user_app_door_sensor
    ../user_app/user_app_vending_machine/user_app_door_sensor/: user_app_door_sensor.c user_app_door_sensor.h
  group user_app/user_app_vending_machine/user_app_electric
    ../user_app/user_app_vending_machine/user_app_electric/: user_app_electric.c user_app_electric.h
  group user_app/user_app_vending_machine/user_app_pc_box
    ../user_app/user_app_vending_machine/user_app_pc_box/: user_app_pc_box.c user_app_pc_box.h
  group user_app/user_app_vending_machine/user_app_relay
    ../user_app/user_app_vending_machine/user_app_relay/: user_app_relay.c user_app_relay.h
  group user_app/user_app_vending_machine/user_app_rs485
    ../user_app/user_app_vending_machine/user_app_rs485/: user_app_rs485.c user_app_rs485.h
  group user_app/user_app_vending_machine/user_app_temperature
    ../user_app/user_app_vending_machine/user_app_temperature/: user_app_temperature.c user_app_temperature.h
  group user_app/user_app_vending_machine/user_app_vib_sensor
    ../user_app/user_app_vending_machine/user_app_vib_sensor/: user_app_vib_sensor.c user_app_vib_sensor.h
  group user_app/user_app_vending_machine/user_comm_vending_machine
    ../user_app/user_app_vending_machine/user_comm_vending_machine/: user_comm_vending_machine.c user_comm_vending_machine.h
  group user_app/user_app_vending_machine/user_irq_input
    ../user_app/user_app_vending_machine/user_irq_input/: user_irq_input.c user_irq_input.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_log
    ../user_app/user_log/: user_log.c user_log.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/mqtt_lib
    ../user_component/mqtt_lib/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_mem/user_external_flash
    ../user_component/user_mem/user_external_flash/: user_external_flash.c user_external_flash.h
  group user_component/user_mem/user_external_flash/external_flash_S25FL216K
    ../user_component/user_mem/user_external_flash/external_flash_S25FL216K/: S25FL216K.c S25FL216K.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_component/user_sim
    ../user_component/user_sim/: user_sim.c user_sim.h user_sim_common.c user_sim_common.h
  group user_component/user_sim/user_ec200
    ../user_component/user_sim/user_ec200u/: user_ec200u.c user_ec200u.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_lpm.c user_lpm.h user_modbus_rtu.c user_modbus_rtu.h user_obis.c user_obis.h user_string.c user_string.h user_time.c user_time.h user_util.c user_util.h
