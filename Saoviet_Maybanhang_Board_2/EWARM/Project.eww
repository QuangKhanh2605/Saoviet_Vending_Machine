<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Saoviet_Maybanhang_Board_2.ewp</path>
  </project>
  <batchBuild />
</workspace>
