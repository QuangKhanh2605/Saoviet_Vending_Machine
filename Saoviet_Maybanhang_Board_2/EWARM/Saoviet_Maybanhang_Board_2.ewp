# IAR project Saoviet_Maybanhang_Board_2.ewp, settings and files
configuration Saoviet_Maybanhang_Board_2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031F6 ST STM32L031F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_ade7953\user_ade7953; ..\user_app\user_app_ade7953; ..\user_app\user_app_comm; ..\user_app\user_app_slave; ..\user_app\user_uart; ..\user_eventdriven; ..\user_util
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Saoviet_Maybanhang_Board_2.hex
  ILINK.IlinkOutputFile: Saoviet_Maybanhang_Board_2.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l031xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c spi.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_iwdg.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group user_app/user_app_ade7953
    ../user_app/user_app_ade7953/: user_app_ade7953.c user_app_ade7953.h
  group user_app/user_app_ade7953/user_ade7953
    ../user_app/user_app_ade7953/user_ade7953/: ade7953.c ade7953.h
  group user_app/user_app_comm
    ../user_app/user_app_comm/: user_app_comm.c user_app_comm.h
  group user_app/user_app_slave
    ../user_app/user_app_slave/: user_app_slave.c user_app_slave.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_modbus_rtu.c user_modbus_rtu.h user_util.c user_util.h
