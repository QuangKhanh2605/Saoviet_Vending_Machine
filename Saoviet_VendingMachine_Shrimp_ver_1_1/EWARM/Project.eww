<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Saoviet_VendingMachine_Shrimp_ver_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
